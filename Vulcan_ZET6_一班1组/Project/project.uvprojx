# Keil uVision project project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: vuclan_zigbee +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User\system;..\User\bsp;..\User\bsp\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c
  group BSP
    ../User/bsp/: bsp.c bsp.h
    ../User/bsp/src/: bsp_led.c bsp_timer.c bsp_key.c bsp_uart.c bsp_uart4.c bsp_uart2.c bsp_uart5.c bsp_spi.c bsp_rc522.c bsp_voice.c bsp_28byj48.c bsp_nt35310_lcd.c
    ../User/bsp/inc/: font.h pic.h
  group SYSTEM
    ../User/system/: stm32f10x_assert.c stm32f10x_it.c sys.h
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_tim.c
